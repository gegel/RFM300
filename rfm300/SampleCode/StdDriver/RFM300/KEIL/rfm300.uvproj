# Keil uVision project rfm300.uvproj, settings and files
target GPIO (MCS-51)
  device: ML51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: rfm300 +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c uart.c wkt.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
  group rf
    ../rf/: cmt_spi3.c cmt2300a.c cmt2300a_hal.c hw_layer.c radio.c if.c
